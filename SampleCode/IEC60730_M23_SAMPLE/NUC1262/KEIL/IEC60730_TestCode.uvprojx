# Keil uVision project IEC60730_TestCode.uvprojx, settings and files
target IEC60730_TestCode (6140000::V6.14::ARMCLANG)
  device: NUC1262SE4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: IEC60730_ClassB_Test
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MUC1262
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\IEC60730_M23_STL;..\post-build;..\..\;.\;..\..\..\IEC60730_M23_Sample\NUC1262\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\iec60730.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
    ../../../../Library/Device/Nuvoton/NUC1262/Source/ARM/: startup_NUC1262.s
  group User
    ../: main.c system_init.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c fmc.c crc.c wdt.c timer.c wwdt.c spi.c adc.c
  group IEC60730_SAFETY_TEST_LIB
    ../../../IEC60730_M23_STL/: ram_march_test.c ram_marchx_wom_test_startup.s ram_marchc_wom_test_startup.s ram_marchc_wom_test_runtime.s pc_test_startup.c stack_test_runtime.c cpureg_test_runtime.s cpureg_test_startup.s interrupt_test_runtime.c flash_test_startup.c flash_test_runtime.c stack_overrun_ptrn.c adc_mux_test_runtime.c global_var.c global_var_backup.c
  group IEC60730_SAFETY_CONTROL
    ../../../IEC60730_M23_STL/: CLASSB_TESTLIB_INIT.c CLASSB_STARTUP_TESTS.c CLASSB_RUNTIME_TESTS.c IEC60730_SAFETY_TEST_LIB.h IEC60730_SAFETY_TEST_LIB.c
software components: CMSIS:CORE 5.6.0
